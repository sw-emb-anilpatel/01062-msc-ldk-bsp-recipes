# Copyright (C) 2023 AVNET Embedded, MSC Technologies GmbH

BRANCH = "msc-renesas_v2021.10_5_10_develop"

UBOOT_URL = "git://github.com/sw-emb-anilpatel/uboot-renesas.git;protocol=https"

SRCREV = "b24549acfdab1c26114dee45e4aa59338c395733"
