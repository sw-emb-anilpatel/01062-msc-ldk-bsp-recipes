# add renesas base image components
require ../../meta-renesas.git/meta-rz-common/include/core-image-renesas-base.inc

